## Sensor_1_Board/Examples/Test/sample.yaml
```yaml
sample:
  description: Example Source Code for the Sensor 1 Board
  name: Sensor 1
```
